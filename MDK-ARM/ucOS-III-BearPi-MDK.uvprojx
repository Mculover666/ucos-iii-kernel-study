# Keil uVision project ucOS-III-BearPi-MDK.uvprojx, settings and files
target ucOS-III-BearPi-MDK (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: ucOS-III-BearPi-MDK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\ucos-iii\uC-OS3\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\ucos-iii\uC-OS3\Source;..\ucos-iii\uC-CPU;..\ucos-iii\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\ucos-iii\uC-LIB;..\ucos-iii\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c sys.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group uC-OS3/port
    ../ucOS-III/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../ucOS-III/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
  group uC-OS3/source
    ../ucOS-III/uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC-OS3/config
    ../ucos-iii/config/: cpu_cfg.h lib_cfg.h os_cfg.h
  group uC-CPU
    ../ucOS-III/uC-CPU/: cpu_core.c
    ../ucOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../ucOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
  group uC-LIB
    ../ucOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Demo
    ../demo/helloworld/: helloworld.c
software components: CMSIS:CORE 4.3.0
